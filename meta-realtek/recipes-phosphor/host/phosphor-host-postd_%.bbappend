SNOOP_DEVICE:realtek = "rts591x-espi-snoop0"
